options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: PreOFDM
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: '"packet_len"'
    occupied_carriers: ((-2, -1, 1, 3), (-3, -1, 1, 2))
    output_is_shifted: 'True'
    pilot_carriers: ((-3, 2), (-2, 3))
    pilot_symbols: ((-1, 1j), (1, -1j), (-1, 1j), (-1j, 1))
    sync_words: ((),)
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '16'
    input_size: fft_len
    tagname: '"frame_len"'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: TimeDomain
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: PreOFDM
  states: {}

connections:
- [digital_ofdm_carrier_allocator_cvc_0, '0', fft_vxx_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', virtual_sink_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [virtual_source_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']

metadata:
  file_format: 1
